# IAR project s6e2ccxj_template.ewp, settings and files
configuration S6E2CCA_Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\common; ..\..\include; ..\..\drivers; ..\..\utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2ccxj_template.srec
  ILINK.IlinkOutputFile: s6e2ccxj_template.out
  ILINK.IlinkIcfFile: linker\s6e2cca_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2CCA_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCIncludePath2: ..\..\common; ..\..\include; C:\PortableApps\Cypress\PDL\2.1.0\drivers; C:\PortableApps\Cypress\PDL\2.1.0\utilities
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2cca_ram.icf
  group common
    ../../common/: system_s6e2cc.c
  group pdl
    ../../../../../../../../PortableApps/Cypress/PDL/2.1.0/drivers/mfs/: mfs.c
    ../../../../../../../../PortableApps/Cypress/PDL/2.1.0/drivers/: pdl.c
    ../: pdl_user.h
  group source
    ../: at_uart.c at_uart.h main.c
    ./: startup_s6e2cc.s
  group util
    ../../../../../../../../PortableApps/Cypress/PDL/2.1.0/utilities/printf_scanf/: uart_io.c uart_io.h
